** sch_path: xschem/Iref/self_bias_tb_mc.sch
**.subckt self_bias_tb_mc
[expr {fals ? "V1 VDD 0 dc {VDD} ac 0 PWL(0 0 {tstart} 0 {tstart+trise} 1.8)
.save i(v1)
.save :(:)
.save "v1vdd0("v1vdd0)
.save dc(dc)
.save {vdd}({vdd})
.save ac(ac)
.save 0(0)
.save pwl(0)
.save 0(0)
.save {tstart}({tstart})
.save 0(0)
.save {tstart+trise}({tstart+trise})
.save 1.8)(1.8)
.save "}]("}])
x1 VDD Vgp 0 self_bias
**** begin user architecture code


* Inclusión de libreria de modelos Sky130 PRIMERO
.lib /foss/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice tt_mm

.option temp=27
.option num_threads=8

**parametros_ldo
.param VDD    = 1.8
.param tstart = 10u
.param trise  = 200u
.param tfall  = 200u
.param tsim   = 'tstart+4*trise+3*tfall'

.control
let mc_runs = 100
let run = 1

let tstart = 10u
let trise  = 200u
let tfall  = 200u
let tsim   = tstart + 4*trise + 3*tfall

set appendwrite
set filetype=ascii

echo === INICIO MONTE CARLO SELF BIAS === > self_bias_mc.txt

while run <= mc_runs

    echo ======================================
    echo CORRIENDO MONTE CARLO ITERACION: $&run
    echo ======================================
    echo --- ITERACION: $&run --- >> self_bias_mc.txt

    * 1. Recalcular el circuito para la nueva muestra estadistica
    reset

    * 2. Transiente (Arranque con PWL)
    tran 1u $&tsim

    * Guardamos SOLO las señales clave en el .raw para no saturar el disco
    write self_bias_mc_tran.raw v(VDD) v(Vgp) v(x1.VDI) v(x1.VR)

    * 3. Medir las tensiones en Pulso 1 (300u) y Pulso 2 (1100u)
    meas tran vgp_p1 FIND v(Vgp)    AT=300u
    meas tran vdi_p1 FIND v(x1.VDI) AT=300u
    meas tran vr_p1  FIND v(x1.VR)  AT=300u

    meas tran vgp_p2 FIND v(Vgp)    AT=1100u
    meas tran vdi_p2 FIND v(x1.VDI) AT=1100u
    meas tran vr_p2  FIND v(x1.VR)  AT=1100u

    let vsgp_p1 = 1.8 - vgp_p1
    let vsgp_p2 = 1.8 - vgp_p2

    * 4. Guardar resultados en el archivo de texto
    echo 'run = $&run' >> self_bias_mc.txt
    echo 'vgp_p1 = $&vgp_p1' >> self_bias_mc.txt
    echo 'vdi_p1 = $&vdi_p1' >> self_bias_mc.txt
    echo 'vr_p1 = $&vr_p1' >> self_bias_mc.txt
    echo 'vsgp_p1 = $&vsgp_p1' >> self_bias_mc.txt
    echo 'vgp_p2 = $&vgp_p2' >> self_bias_mc.txt
    echo 'vdi_p2 = $&vdi_p2' >> self_bias_mc.txt
    echo 'vr_p2 = $&vr_p2' >> self_bias_mc.txt
    echo 'vsgp_p2 = $&vsgp_p2' >> self_bias_mc.txt

    * 5. CLAVE: Borrar los vectores de la RAM de esta iteracion
    * (Los contadores como 'run' y 'mc_runs' viven en 'const', así que no se borran)
    destroy all

    let run = run + 1

end

echo === FIN MONTE CARLO SELF BIAS === >> self_bias_mc.txt

.endc


**** end user architecture code
**.ends

* expanding   symbol:  self_bias.sym # of pins=3
** sym_path: xschem/Iref/self_bias.sym
** sch_path: xschem/Iref/self_bias.sch
.subckt self_bias VDD Vgp VSS
*.iopin Vgp
*.iopin VDD
*.iopin VSS
XMn1 VDI VR VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XMn2 Vgp VDI VR VSS sky130_fd_pr__nfet_01v8 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XMs3 VDinv VR VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XMs1 Vgp VDinv VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1
+ + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29
+ / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XMp4 Vgp Vgp VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=17.8 nf=1 ad='int((1 + 1)/2) * 17.8 / 1 * 0.29' as='int((1
+ + 2)/2) * 17.8 / 1 * 0.29' pd='2*int((1 + 1)/2) * (17.8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (17.8 / 1
+ + 0.29)' nrd='0.29 / 17.8 ' nrs='0.29 / 17.8 ' sa=0 sb=0 sd=0 mult=1 m=1
XMp3 VDI Vgp VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=17.8 nf=1 ad='int((1 + 1)/2) * 17.8 / 1 * 0.29' as='int((1
+ + 2)/2) * 17.8 / 1 * 0.29' pd='2*int((1 + 1)/2) * (17.8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (17.8 / 1
+ + 0.29)' nrd='0.29 / 17.8 ' nrs='0.29 / 17.8 ' sa=0 sb=0 sd=0 mult=1 m=1
XMs2 VDinv VR VDD VDD sky130_fd_pr__pfet_01v8_lvt L=10 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1
+ + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29
+ / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XR1 VSS VR VSS sky130_fd_pr__res_iso_pw W=0.35 L=5.5 m=1
.ends

.end
