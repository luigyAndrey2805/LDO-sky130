** sch_path: xschem/Iref/self_bias_tb.sch
**.subckt self_bias_tb
[expr {fals ? "V1 VDD 0 dc {VDD} ac 0 PWL(0 0 {tstart} 0 {tstart+trise} 1.8 {tstart+2*trise} 1.8 {tstart+2*trise+tfall} 0 {tstart+2*trise+2*tfall} 0 {tstart+3*trise+2*tfall} 1.8 {tstart+4*trise+2*tfall} 1.8 {tstart+4*trise+3*tfall} 0 )
.save i(v1)
.save :(:)
.save "v1vdd0("v1vdd0)
.save dc(dc)
.save {vdd}({vdd})
.save ac(ac)
.save 0(0)
.save pwl(0)
.save 0(0)
.save {tstart}({tstart})
.save 0(0)
.save {tstart+trise}({tstart+trise})
.save 1.8(1.8)
.save {tstart+2*trise}({tstart+2*trise})
.save 1.8(1.8)
.save {tstart+2*trise+tfall}({tstart+2*trise+tfall})
.save 0(0)
.save {tstart+2*trise+2*tfall}({tstart+2*trise+2*tfall})
.save 0(0)
.save {tstart+3*trise+2*tfall}({tstart+3*trise+2*tfall})
.save 1.8(1.8)
.save {tstart+4*trise+2*tfall}({tstart+4*trise+2*tfall})
.save 1.8(1.8)
.save {tstart+4*trise+3*tfall}({tstart+4*trise+3*tfall})
.save 0)(0)
.save "}]("}])
x1 VDD Vgp 0 self_bias
**** begin user architecture code




* 1. Inclusión de libreria de modelos Sky130 PRIMERO
.lib /foss/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.option temp=27
.option num_threads=8

**parametros_ldo
.param VDD = 1.8



.param tstart   = 10u
.param trise    = 200u
.param tfall    = 200u

.param tsim = 'tstart+2*trise+tfall'



.control
let tstart   = 10u
let trise    = 200u
let tfall    = 200u

let tsim = '$&tstart+4*$&trise+3*$&tfall'

save all



* Ms2 (pfet_01v8_lvt)
save @m.x1.xMs2.msky130_fd_pr__pfet_01v8_lvt[gm]
save @m.x1.xMs2.msky130_fd_pr__pfet_01v8_lvt[gds]
save @m.x1.xMs2.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xMs2.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.x1.xMs2.msky130_fd_pr__pfet_01v8_lvt[vds]
save @m.x1.xMs2.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.x1.xMs2.msky130_fd_pr__pfet_01v8_lvt[vdsat]

* Mp3 (pfet_01v8_lvt)
save @m.x1.xMp3.msky130_fd_pr__pfet_01v8_lvt[gm]
save @m.x1.xMp3.msky130_fd_pr__pfet_01v8_lvt[gds]
save @m.x1.xMp3.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xMp3.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.x1.xMp3.msky130_fd_pr__pfet_01v8_lvt[vds]
save @m.x1.xMp3.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.x1.xMp3.msky130_fd_pr__pfet_01v8_lvt[vdsat]

* Mp4 (pfet_01v8_lvt)
save @m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[gm]
save @m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[gds]
save @m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[vds]
save @m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[vdsat]

* Ms1 (nfet_01v8)
save @m.x1.xMs1.msky130_fd_pr__nfet_01v8[gm]
save @m.x1.xMs1.msky130_fd_pr__nfet_01v8[gds]
save @m.x1.xMs1.msky130_fd_pr__nfet_01v8[id]
save @m.x1.xMs1.msky130_fd_pr__nfet_01v8[vgs]
save @m.x1.xMs1.msky130_fd_pr__nfet_01v8[vds]
save @m.x1.xMs1.msky130_fd_pr__nfet_01v8[vth]
save @m.x1.xMs1.msky130_fd_pr__nfet_01v8[vdsat]

* Ms3 (nfet_01v8)
save @m.x1.xMs3.msky130_fd_pr__nfet_01v8[gm]
save @m.x1.xMs3.msky130_fd_pr__nfet_01v8[gds]
save @m.x1.xMs3.msky130_fd_pr__nfet_01v8[id]
save @m.x1.xMs3.msky130_fd_pr__nfet_01v8[vgs]
save @m.x1.xMs3.msky130_fd_pr__nfet_01v8[vds]
save @m.x1.xMs3.msky130_fd_pr__nfet_01v8[vth]
save @m.x1.xMs3.msky130_fd_pr__nfet_01v8[vdsat]

* Mn1 (nfet_01v8)
save @m.x1.xMn1.msky130_fd_pr__nfet_01v8[gm]
save @m.x1.xMn1.msky130_fd_pr__nfet_01v8[gds]
save @m.x1.xMn1.msky130_fd_pr__nfet_01v8[id]
save @m.x1.xMn1.msky130_fd_pr__nfet_01v8[vgs]
save @m.x1.xMn1.msky130_fd_pr__nfet_01v8[vds]
save @m.x1.xMn1.msky130_fd_pr__nfet_01v8[vth]
save @m.x1.xMn1.msky130_fd_pr__nfet_01v8[vdsat]

* Mn2 (nfet_01v8)
save @m.x1.xMn2.msky130_fd_pr__nfet_01v8[gm]
save @m.x1.xMn2.msky130_fd_pr__nfet_01v8[gds]
save @m.x1.xMn2.msky130_fd_pr__nfet_01v8[id]
save @m.x1.xMn2.msky130_fd_pr__nfet_01v8[vgs]
save @m.x1.xMn2.msky130_fd_pr__nfet_01v8[vds]
save @m.x1.xMn2.msky130_fd_pr__nfet_01v8[vth]
save @m.x1.xMn2.msky130_fd_pr__nfet_01v8[vdsat]




set filetype=ascii
op
write self_bias_op.raw


* 1. Calculamos y guardamos los valores
let vsg_val = v(vdd) - v(vgp)
let ibias_val_uA = '(@m.x1.xMp4.msky130_fd_pr__pfet_01v8_lvt[id])*1000000'

* 2. Imprimimos el texto junto con el valor de la variable
echo VSGP = $&vsg_val
echo ibias = $&ibias_val_uA

tran $&tstart $&tsim


.endc



**** end user architecture code
**.ends

* expanding   symbol:  self_bias.sym # of pins=3
** sym_path: xschem/Iref/self_bias.sym
** sch_path: xschem/Iref/self_bias.sch
.subckt self_bias VDD Vgp VSS
*.iopin Vgp
*.iopin VDD
*.iopin VSS
XMn1 VDI VR VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XMn2 Vgp VDI VR VSS sky130_fd_pr__nfet_01v8 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XMs3 VDinv VR VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XMs1 Vgp VDinv VSS VSS sky130_fd_pr__nfet_01v8 L=1 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29' as='int((1
+ + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)' nrd='0.29
+ / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XMp4 Vgp Vgp VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=17.8 nf=1 ad='int((1 + 1)/2) * 17.8 / 1 * 0.29' as='int((1
+ + 2)/2) * 17.8 / 1 * 0.29' pd='2*int((1 + 1)/2) * (17.8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (17.8 / 1
+ + 0.29)' nrd='0.29 / 17.8 ' nrs='0.29 / 17.8 ' sa=0 sb=0 sd=0 mult=1 m=1
XMp3 VDI Vgp VDD VDD sky130_fd_pr__pfet_01v8_lvt L=1 W=17.8 nf=1 ad='int((1 + 1)/2) * 17.8 / 1 * 0.29' as='int((1
+ + 2)/2) * 17.8 / 1 * 0.29' pd='2*int((1 + 1)/2) * (17.8 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (17.8 / 1
+ + 0.29)' nrd='0.29 / 17.8 ' nrs='0.29 / 17.8 ' sa=0 sb=0 sd=0 mult=1 m=1
XMs2 VDinv VR VDD VDD sky130_fd_pr__pfet_01v8_lvt L=10 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1
+ + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29
+ / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XR1 VSS VR VSS sky130_fd_pr__res_iso_pw W=0.35 L=5.5 m=1
.ends

.end
